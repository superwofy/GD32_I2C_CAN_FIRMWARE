# Keil uVision project GD32_I2C_CAN.uvprojx, settings and files
target GD32C_CAN (6180000::V6.18::ARMCLANG)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32_I2C_CAN_FIRMWARE +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32C10X_MD, __FPU_PRESENT
  c include: .\CMSIS;.\GD32C10x-Firmware\Include;.\Application;.\CMSIS\GD\GD32C10x\Include;.\GD32C10x-Peripherals;.\GD32C10x-EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Application
    ./Application/: main.c gd32c10x_it.c dual_dfs.h
  group Docs
    ./Docs/: Readme.txt
  group GD32C10x-EVAL
    ./GD32C10x-EVAL/: gd32c10x_eval.c
  group GD32C10x-Peripherals
    ./GD32C10x-Peripherals/: i2c.c can.c systick.c lgi_basic.c
  group GD32C10x-Firmware
    ./GD32C10x-Firmware/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group GD32C10x-Startup
    ./GD32C10x-Startup/: startup_gd32c10x.s
